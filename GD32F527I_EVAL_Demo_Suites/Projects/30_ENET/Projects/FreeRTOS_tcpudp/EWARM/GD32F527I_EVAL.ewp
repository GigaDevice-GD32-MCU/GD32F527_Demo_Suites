# IAR project GD32F527I_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F527xS GD32F527xS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32F527
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\inc; ..\..\..\Third_party\lwip-2.1.2\src\include; ..\..\..\Third_party\lwip-2.1.2\src\include\ipv4; ..\..\..\..\..\Utilities; ..\inc; ..\..\..\Third_party\lwip-2.1.2\src\include; ..\..\..\Third_party\lwip-2.1.2\src\include\ipv4; ..\..\..\Third_party\lwip-2.1.2\src\include\netif; ..\..\..\Third_party\lwip-2.1.2\src\include\lwip; ..\..\..\Third_party\lwip-2.1.2\port\GD32F527; ..\..\..\Third_party\lwip-2.1.2\port\GD32F527\FreeRTOS; ..\..\..\Third_party\lwip-2.1.2\port\GD32F527\arch; ..\..\..\Third_party\FreeRTOS-10.3.1\include; ..\..\..\Third_party\FreeRTOS-10.3.1\portable\IAR\ARM_CM33_NTZ; ..\..\..\Third_party\FreeRTOS-10.3.1\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include; ..\..\..\..\..\..\GD32F527_Firmware_Library\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: USE_STDPERIPH_DRIVER; GD32F470
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: GD32F527I_EVAL.srec
  ILINK.IlinkOutputFile: GD32F527I_EVAL.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Application
    ../src/: gd32f527_enet_eval.c gd32f527_it.c hello_gigadevice.c main.c netconf.c tcp_client.c udp_echo.c
  group CMSIS
    ../../../../../../GD32F527_Firmware_Library/CMSIS/GD/GD32F527/Source/: system_gd32f527.c
  group Doc
    ../: readme.txt
  group FreeRTOS
    ../../../Third_party/FreeRTOS-10.3.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/MemMang/: heap_4.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group GD32F527_EVAL
    ../../../../../Utilities/: gd32f527i_eval.c
  group GD32F527_Peripherals
    ../../../../../../GD32F527_Firmware_Library/GD32F527_standard_peripheral/Source/: gd32f527_adc.c gd32f527_can.c gd32f527_cau.c gd32f527_cau_aes.c gd32f527_cau_des.c gd32f527_cau_tdes.c gd32f527_crc.c gd32f527_ctc.c gd32f527_dac.c gd32f527_dbg.c gd32f527_dci.c gd32f527_dma.c gd32f527_enet.c gd32f527_exmc.c gd32f527_exti.c gd32f527_fmc.c gd32f527_fwdgt.c gd32f527_gpio.c gd32f527_hau.c gd32f527_hau_sha_md5.c gd32f527_i2c.c gd32f527_i2c_add.c gd32f527_ipa.c gd32f527_iref.c gd32f527_misc.c gd32f527_pkcau.c gd32f527_pmu.c gd32f527_rcu.c gd32f527_rtc.c gd32f527_sai.c gd32f527_sdio.c gd32f527_spi.c gd32f527_syscfg.c gd32f527_timer.c gd32f527_tli.c gd32f527_trng.c gd32f527_usart.c gd32f527_wwdgt.c
  group Lwip
    ../../../Third_party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../Third_party/lwip-2.1.2/src/netif/: ethernet.c
  group Lwip_port
    ../../../Third_party/lwip-2.1.2/port/GD32F527/FreeRTOS/: ethernetif.c sys_arch.c
  group Startup
    ../../../../../../GD32F527_Firmware_Library/CMSIS/GD/GD32F527/Source/IAR/: startup_gd32f527.s
