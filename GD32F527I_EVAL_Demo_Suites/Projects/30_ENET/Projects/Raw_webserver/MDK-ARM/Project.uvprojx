# Keil uVision project Project.uvprojx, settings and files
target GD32F527I_EVAL (6160000::V6.16::ARMCLANG)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F527_DFP.1.0.1
  cpu: IRAM(0x20000000,0x080000) IROM(0x08000000,0x780000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: GD32F527I_EVAL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: GD32F527
  c include: ..\..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include;..\..\..\..\..\Utilities;..\inc;..\..\..\Third_party\lwip-2.1.2\src\include;..\..\..\Third_party\lwip-2.1.2\src\include\ipv4;..\..\..\Third_party\lwip-2.1.2\src\include\netif;..\..\..\Third_party\lwip-2.1.2\src\include\lwip;..\..\..\Third_party\lwip-2.1.2\port\GD32F527;..\..\..\Third_party\lwip-2.1.2\port\GD32F527\Basic;..\..\..\..\..\..\GD32F527_Firmware_Library\CMSIS;..\..\..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application
    ../src/: main.c netconf.c http_adc_led.c gd32f527_enet_eval.c gd32f527_it.c
  group GD32F527_Peripherals
    ../../../../../../GD32F527_Firmware_Library/GD32F527_standard_peripheral/Source/: gd32f527_adc.c gd32f527_can.c gd32f527_cau.c gd32f527_cau_aes.c gd32f527_cau_des.c gd32f527_cau_tdes.c gd32f527_crc.c gd32f527_ctc.c gd32f527_dac.c gd32f527_dbg.c gd32f527_dci.c gd32f527_dma.c gd32f527_enet.c gd32f527_exmc.c gd32f527_exti.c gd32f527_fmc.c gd32f527_fwdgt.c gd32f527_gpio.c gd32f527_hau.c gd32f527_hau_sha_md5.c gd32f527_i2c.c gd32f527_i2c_add.c gd32f527_ipa.c gd32f527_iref.c gd32f527_misc.c gd32f527_pkcau.c gd32f527_pmu.c gd32f527_rcu.c gd32f527_rtc.c gd32f527_sai.c gd32f527_sdio.c gd32f527_spi.c gd32f527_syscfg.c gd32f527_timer.c gd32f527_tli.c gd32f527_trng.c gd32f527_usart.c gd32f527_wwdgt.c
  group Lwip
    ../../../Third_party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../Third_party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.1.2/src/netif/: ethernet.c
  group Lwip_port
    ../../../Third_party/lwip-2.1.2/port/GD32F527/Basic/: ethernetif.c
  group Lwip_http
    ../src/: httpd.c fs.c
  group CMSIS
    ../../../../../../GD32F527_Firmware_Library/CMSIS/GD/GD32F527/Source/: system_gd32f527.c
  group GD32F527_EVAL
    ../../../../../Utilities/: gd32f527i_eval.c
  group Startup
    ../../../../../../GD32F527_Firmware_Library/CMSIS/GD/GD32F527/Source/ARM/: startup_gd32f527.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
