# IAR project GD32F527I_EVAL.ewp, settings and files
configuration GD32F527 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F527xS GD GD32F527xS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32F527
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include; ..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include; ..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD; ..\..\..\Utilities; ..\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32F527I_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32f527_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F527_Firmware_Library/CMSIS/GD/GD32F527/Source/: system_gd32f527.c
  group Doc
    ../: readme.txt
  group GD32F527_EVAL
    ../../../Utilities/: gd32f527i_eval.c
  group GD32F527_Peripherals
    ../../../../GD32F527_Firmware_Library/GD32F527_standard_peripheral/Source/: gd32f527_adc.c gd32f527_can.c gd32f527_cau.c gd32f527_cau_aes.c gd32f527_cau_des.c gd32f527_cau_tdes.c gd32f527_crc.c gd32f527_ctc.c gd32f527_dac.c gd32f527_dbg.c gd32f527_dci.c gd32f527_dma.c gd32f527_enet.c gd32f527_exmc.c gd32f527_exti.c gd32f527_fmc.c gd32f527_fwdgt.c gd32f527_gpio.c gd32f527_hau.c gd32f527_hau_sha_md5.c gd32f527_i2c.c gd32f527_i2c_add.c gd32f527_ipa.c gd32f527_iref.c gd32f527_misc.c gd32f527_pkcau.c gd32f527_pmu.c gd32f527_rcu.c gd32f527_rtc.c gd32f527_sai.c gd32f527_sdio.c gd32f527_spi.c gd32f527_syscfg.c gd32f527_timer.c gd32f527_tli.c gd32f527_trng.c gd32f527_usart.c gd32f527_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: dci_ov2640.c exmc_sdram.c picture.c sccb.c
  group Startup
    ../../../../GD32F527_Firmware_Library/CMSIS/GD/GD32F527/Source/IAR/: startup_gd32f527.s
