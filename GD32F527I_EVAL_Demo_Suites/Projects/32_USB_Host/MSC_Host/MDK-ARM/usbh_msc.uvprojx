# Keil uVision project usbh_msc.uvprojx, settings and files
target USBFS_usbh_msc (6130001::V6.13.1::.\ARMCLANG)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x080000) IROM(0x08000000,0x780000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: USBFS_usbh_msc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32F527,USE_USB_FS
  c include: ..\inc;..\..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\driver\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\common;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\host\core\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\host\class\msc\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\class\msc;..\..\..\..\Utilities;..\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application
    ../src/: main.c usbh_usr.c gd32f527_it.c gd32f527_usb_hw.c
  group CMSIS
    ../src/: system_gd32f527.c
  group GD32F527_Peripherals
    ../../../../../GD32F527_Firmware_Library/GD32F527_standard_peripheral/Source/: gd32f527_dma.c gd32f527_exmc.c gd32f527_exti.c gd32f527_fmc.c gd32f527_gpio.c gd32f527_misc.c gd32f527_rcu.c gd32f527_sdio.c gd32f527_syscfg.c gd32f527_usart.c gd32f527_timer.c gd32f527_tli.c gd32f527_pmu.c
  group GD32F527_EVAL
    ../src/: lcd_font.c lcd_log.c gd32f527i_lcd_eval.c gd32f527i_eval_exmc_sdram.c gd32f527i_eval.c
  group USB_Driver
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group Startup
    ./: startup_gd32f527.s
  group FAT_FS
    ../fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
target USBHS_usbh_msc (6130001::V6.13.1::.\ARMCLANG)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.0.1
  cpu: as above
  output: USBHS_usbh_msc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32F527,USE_USB_HS,USE_ULPI_PHY
  c include: ..\inc;..\..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_driver\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\driver\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\host\core\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\common;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\host\class\msc\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\class\msc;..\..\..\..\Utilities;..\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
software components: CMSIS:CORE 5.3.0
