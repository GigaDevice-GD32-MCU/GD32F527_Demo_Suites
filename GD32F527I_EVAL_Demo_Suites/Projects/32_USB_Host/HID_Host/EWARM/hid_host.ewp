# IAR project hid_host.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F527xS GD GD32F527xS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: GD32F527; USE_USB_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Utilities; ..\..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\common; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\host\core\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\host\class\hid\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\class\hid; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\driver\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: USBFS_usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: GD32F527; USE_USB_HS; USE_ULPI_PHY
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: USBHS_usbh_hid.out
  group Application
    ../src/: gd32f527_it.c gd32f527_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../src/: system_gd32f527.c
  group Doc
    ../: readme.txt
  group GD32F527_EVAL
    ../src/: gd32f527i_eval.c gd32f527i_eval_exmc_sdram.c gd32f527i_lcd_eval.c lcd_font.c lcd_log.c
  group GD32F527_Peripherals
    ../../../../../GD32F527_Firmware_Library/GD32F527_standard_peripheral/Source/: gd32f527_dma.c gd32f527_exmc.c gd32f527_exti.c gd32f527_fmc.c gd32f527_gpio.c gd32f527_misc.c gd32f527_pmu.c gd32f527_rcu.c gd32f527_syscfg.c gd32f527_timer.c gd32f527_tli.c gd32f527_usart.c
  group Startup
    ../../../../../GD32F527_Firmware_Library/CMSIS/GD/GD32F527/Source/IAR/: startup_gd32f527.s
  group USB_Class
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group USB_Driver
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
