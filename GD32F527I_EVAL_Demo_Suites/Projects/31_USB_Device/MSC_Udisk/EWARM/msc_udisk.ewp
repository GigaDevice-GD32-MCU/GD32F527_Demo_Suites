# IAR project msc_udisk.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F527xS GD GD32F527xS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F527
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\device\class\msc\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\device\core\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\driver\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\class\msc; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\common; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: audio.srec
  ILINK.IlinkOutputFile: USBFS_msc_udisk.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_HS; USE_ULPI_PHY; GD32F527
  ICCARM.CCIncludePath2: ..\..\..\..\Utilities; ..\..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\device\class\msc\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\device\core\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\driver\Include; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\class\msc; ..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\common; ..\inc
  OBJCOPY.OOCOutputFile: msc_udisk.srec
  ILINK.IlinkOutputFile: USBHS_msc_udisk.out
  group Application
    ../src/: app.c gd32f527_hw.c gd32f527_it.c sram_msd.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32f527.c
  group Doc
    ../: readme.txt
  group GD32F527_EVAL
    ../../../../Utilities/: gd32f527i_eval.c
  group GD32F527_Peripherals
    ../../../../../GD32F527_Firmware_Library/GD32F527_standard_peripheral/Source/: gd32f527_ctc.c gd32f527_exti.c gd32f527_gpio.c gd32f527_misc.c gd32f527_pmu.c gd32f527_rcu.c gd32f527_syscfg.c gd32f527_timer.c gd32f527_usart.c
  group Startup
    ../../../../../GD32F527_Firmware_Library/CMSIS/GD/GD32F527/Source/IAR/: startup_gd32f527.s
  group USB_Class
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group USB_Device
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
