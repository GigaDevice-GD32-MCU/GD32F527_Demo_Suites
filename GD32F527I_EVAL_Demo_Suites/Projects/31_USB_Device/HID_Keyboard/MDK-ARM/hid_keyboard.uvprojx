# Keil uVision project hid_keyboard.uvprojx, settings and files
target USBFS_hid_keyboard (6130001::V6.13.1::.\ARMCLANG)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F527_DFP.1.0.1
  cpu: IRAM(0x20000000,0x080000) IROM(0x08000000,0x780000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: USBFS_hid_keyboard +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32F527,USE_USB_FS
  c include: ..\inc;..\..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\device\class\hid\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\device\core\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\driver\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\class\hid;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\common;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application
    ../src/: gd32f527_it.c app.c gd32f527_hw.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32f527.c
  group GD32F527_EVAL
    ../../../../Utilities/: gd32f527i_eval.c
  group GD32F527_Peripherals
    ../../../../../GD32F527_Firmware_Library/GD32F527_standard_peripheral/Source/: gd32f527_ctc.c gd32f527_dma.c gd32f527_exti.c gd32f527_gpio.c gd32f527_misc.c gd32f527_pmu.c gd32f527_rcu.c gd32f527_syscfg.c gd32f527_timer.c gd32f527_usart.c
  group USB_Drivers
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../GD32F527_Firmware_Library/GD32F527_usb_library/device/class/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../../GD32F527_Firmware_Library/CMSIS/GD/GD32F527/Source/ARM/: startup_gd32f527.s
  group Doc
    ../: readme.txt
target USBHS_hid_keyboard (6130001::V6.13.1::.\ARMCLANG)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F527_DFP.1.0.1
  cpu: as above
  output: USBHS_hid_keyboard +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32F527,USE_USB_HS,USE_ULPI_PHY
  c include: ..\inc;..\..\..\..\Utilities;..\..\..\..\..\GD32F527_Firmware_Library\CMSIS\GD\GD32F527\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_standard_peripheral\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\device\class\hid\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\device\core\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\driver\Include;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\class\hid;..\..\..\..\..\GD32F527_Firmware_Library\GD32F527_usb_library\ustd\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
software components: CMSIS:CORE 5.3.0
